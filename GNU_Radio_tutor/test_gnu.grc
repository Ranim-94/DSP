options:
  parameters:
    generate_options: qt_gui
    id: test_gnu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Signal_Type
  id: variable_qtgui_chooser
  parameters:
    label0: Cosine
    label1: Square
    num_opts: '2'
    option0: '100'
    option1: '102'
    type: int
    value: '100'
    widget: radio_buttons
  states: {}
- name: freq_change
  id: variable_qtgui_range
  parameters:
    start: 1e3
    step: '500'
    stop: 1e4
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_change
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: Signal_Type
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: Spectrume
    norm_window: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
